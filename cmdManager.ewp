# IAR project cmdManager.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 256
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m16 ATmega16
  ICCAVR.newCCIncludePaths: ..\..\Src; ..\..\..\Stream\Src; ..\..\..\Str\Src
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm16.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.GenDeviceSelectMenu: 3
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group (top)
    ./: CMD_LED.c CMD_TEST.c main.c UARTStream.c
    ../../Src/: CmdManager.c
    ../../../Stream/Src/: InputStream.c OutputStream.c StreamBuffer.c
    ../../../Str/Src/: Str.c
